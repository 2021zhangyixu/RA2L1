# Keil uVision project project3.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: R7FA2E1A9 Renesas
  pack: Renesas.RA_DFP.4.2.0
  cpu: IRAM(0x20004000,0x004000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: project3
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src\led;.\src\usart9
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20004000 size 0x4000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
    ./src/led/: led.c led.h
    ./src/usart9/: usart9.c usart9.h
software components: Flex Software:RA Configuration 1.0.0
